options:
  parameters:
    author: HA7DN
    copyright: HA5KFU 2025
    generate_options: qt_gui
    id: airband
    output_language: python
    title: Airband AM receiver
  states: {}

blocks:
- name: offset_freq
  id: variable
  parameters:
    value: '50_000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '300_000'
  states: {}
- name: volume_mult
  id: variable_qtgui_range
  parameters:
    label: '"AF gain (dB)"'
    start: '0'
    step: '1'
    stop: '40'
    value: '15'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '50_000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate//10
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      Since RTL-SDR samples are mapped
      -1 -> 0
      0 -> 128
      +1 -> 255
      We need to remove the DC offset
      Note: this is NOT 2's complement!
    const: '128'
    type: byte
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: Take the absolute value
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    comment: |-
      De-interleave
      Also divide by 127
    scale_factor: '127'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Multiply by the slider value
    const: 10**(volume_mult/20)
    type: float
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: ''
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset_freq
    comment: |-
      This block mixes, filters and decimates at the same time
      Very handy, and efficient, but not simple
    decim: '10'
    samp_rate: samp_rate
    taps: ' firdes.low_pass(1,samp_rate,3000, 200)'
    type: ccc
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: teto.sch.bme.hu
    comment: Connect to central RTL-TCP server
    port: '7373'
    server: 'False'
    type: byte
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'RTL-SDR settings: "rtl_sdr -f 127350000 -s 300000 -g 25 -"'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: This displays a waterfall of our AM signal
    fc: '0'
    fftsize: '2048'
    type: complex
    update_time: '0.04'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_rotator_cc_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_rotator_cc_0, '0', low_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [network_tcp_source_0, '0', blocks_add_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
