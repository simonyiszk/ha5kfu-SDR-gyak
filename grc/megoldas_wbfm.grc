options:
  parameters:
    author: HA7DN
    copyright: HA5KFU 2025
    generate_options: qt_gui
    id: airband
    output_language: python
    title: Airband AM receiver
  states: {}

blocks:
- name: offset_freq
  id: variable
  parameters:
    value: '50_000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '300_000'
  states: {}
- name: volume_mult
  id: variable_qtgui_range
  parameters:
    label: '"AF gain (dB)"'
    start: '0'
    step: '1'
    stop: '40'
    value: '15'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    comment: Magic block that does everything
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Play audio
    samp_rate: samp_rate//10
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      Since RTL-SDR samples are mapped
      -1 -> 0
      0 -> 128
      +1 -> 255
      We need to remove the DC offset
      Note: this is NOT 2's complement!
    const: '128'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    comment: |-
      De-interleave
      Also divide by 127
    scale_factor: '127'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Multiply by the slider value
    const: 10**(volume_mult/20)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Decrease volume, 
      it would be VERY loud otherwise
    const: 1/20
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: teto.sch.bme.hu
    comment: Connect to central RTL-TCP server
    port: '7373'
    server: 'False'
    type: byte
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'RTL-SDR settings: "rtl_sdr -f 103300000 -s 300000 -g 25 -"'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', analog_wfm_rcv_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [network_tcp_source_0, '0', blocks_add_const_vxx_0, '0']

metadata:
  file_format: 1
